# Keil uVision project TOUCH.uvprojx, settings and files
target TOUCH (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TOUCH +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\STM32F10x_FWLib\inc;..\CORE;..\USER;..\XTinyRTOS\inc;..\lwip-2.1.2\src\apps\http;..\lwip-2.1.2;..\lwip-2.1.2\src\include;..\lwip-2.1.2\arch;..\lwip-2.1.2\src\include\compat\posix;..\ff13c\source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c myiic.c RTOS_APP.c RTOS_APP.h net_init.c
  group HARDWARE
    ./: tim3.c tim3.h dm9000.c sdio_sdcard.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_sdio.c stm32f10x_dma.c
  group XTinyRTOS
    ../XTinyRTOS/src/: RTOS_core.c RTOS_mem.c RTOS_msg.c RTOS_mutex.c RTOS_sem.c RTOS_task.c RTOS_timer.c
    ../XTinyRTOS/inc/: RTOS_core.h RTOS_mem.h RTOS_msg.h RTOS_mutex.h RTOS_sem.h RTOS_task.h RTOS_timer.h RTOS_type.h
  group lwip_api
    ../lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip_core
    ../lwip-2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwip_netif
    ../lwip-2.1.2/src/netif/: ethernet.c ethernetif.c
  group lwip_arch
    ../lwip-2.1.2/arch/: cc.h cpu.h lwipopts.h perf.h sys_arch.c sys_arch.h
  group lwip_apps
    ../lwip-2.1.2/src/apps/http/: altcp_proxyconnect.c fs.c http_client.c httpd.c
  group FATFS
    ../ff13c/source/: diskio.c ff.c ffsystem.c ffunicode.c
